# Keil uVision project IAP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IAP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Bsp;..\..\Bsp\inc;..\..\Bsp\src;..\..\Doc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS;..\..\FatFS\src;..\..\FatFS\src\option;..\..\User\fonts;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usbd_mass_storage;..\..\Libraries\STM32_USB_Device_Library\Core\src;..\..\Libraries\STM32_USB_Device_Library\Class\msc\src;..\..\Libraries\STM32_USB_OTG_Driver\src;..\..\Bsp;..\..\Bsp\algo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../../Bsp/: stm32f4xx_assert.c stm32f4xx_it.c bsp.c bsp_swd.c
    ../../Bsp/src/: bsp_key.c bsp_user_lib.c bsp_led.c bsp_uart_fifo.c bsp_timer.c bsp_sdio_sd.c bsp_oled.c bsp_spi_flash.c bsp_beep.c bsp_tim_pwm.c bsp_protocol.c
  group User
    ../../User/: main.c demo_sdio_fatfs.c demo_spi_flash.c HexToBin.c IAP.c
    ../../Bsp/: bsp_swd_flash.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group FatFS
    ../../FatFS/src/: ff.c diskio.c
    ../../FatFS/: FatFS移植记录.txt
  group Font
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c 说明.txt
  group USB MassStorage
    ../../User/usbd_mass_storage/: usb_bsp.c usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USB_Device_Library
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c usb_core.c
